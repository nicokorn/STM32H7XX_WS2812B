<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32H7XX_WS2812B.ewp</path>
  </project>
  <batchBuild />
</workspace>
